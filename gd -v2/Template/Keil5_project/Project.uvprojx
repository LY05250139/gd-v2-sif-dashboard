# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F107VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_common;..\..\Firmware\GD32F10x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f10x_it.c main.c systick.c
    ../../Core/Src/: adc.c AtCmd.c ble.c BQ40Z50.c Camp.c coulom.c DS1302.c eeprom.c Gatt.c gps.c GsmCom.c JbsBms.c key.c Keyboard.c lcd.c Menu.c mqtt.c OffGrid.c payg.c Pump.c SmartBms.c temp.c Timer.c at24cxx.c i2c.c Sif.c
    ./: dashborad.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group Utilities
    ../../Utilities/: gd32f10x_eval.c
  group Doc
    ../: readme.txt
target GD32F10X_MD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (5060960::V5.06 update 7 (build 960)::.\ARM_compiler_5.06)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BridgewareV2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_common;..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\Core\Inc;..\..\Core\Inc\bms309;D:\keil5\ARM\ARMCLANG\include;D:\keil5\GigaDevice\GD32F10x_DFP\2.0.3\Device\Utilities;..\..\Template;..\..\Utilities;..\Keil5_project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target GD32F10X_XD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VK GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
